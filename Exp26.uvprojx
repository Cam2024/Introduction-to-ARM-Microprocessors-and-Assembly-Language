# Keil uVision project Exp26.uvprojx, settings and files
target frdm kl46z (6190000::V6.19::ARMCLANG)
  device: MKL46Z256xxx4 Freescale
  pack: NXP.MKL46Z4_DFP.10.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Exp26
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group Source Files
    ./: exp26_asm.s main.c
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0
